options:
  parameters:
    author: huangziang
    generate_options: qt_gui
    id: GFSK_Receiver
    output_language: python
    title: GFSK_Receiver
  states: {}

blocks:
- name: SPS
  id: variable
  parameters:
    value: '52'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: signal_frequency
  id: variable
  parameters:
    value: '433200000'
  states: {}
- name: signal_sensitivity
  id: variable
  parameters:
    value: '1.5756'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.05'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.05'
    samples_per_symbol: SPS
    sensitivity: 1/signal_sensitivity
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(
              self,
              # cmd_id=0x0a01
              cmd_id_1: int = 0x0A01,
              hero_position: tuple = (0, 0),
              engineer_position: tuple = (0, 0),
              infentry_position_1: tuple = (0, 0),
              infentry_position_2: tuple = (0, 0),
              drone_position: tuple = (0, 0),
              sentinel_position: tuple = (0, 0),
              # cmd_id=0x0a02
              cmd_id_2: int = 0x0A02,
              hero_blood: int = 200,
              engineer_blood: int = 200,
              infentry_blood_1: int = 200,
              infentry_blood_2: int = 200,
              save_blood: int = 0x0000,
              sentinel_blood: int = 200,
              # cmd_id=0x0a03
              cmd_id_3: int = 0x0A03,
              hero_ammunition: int = 100,
              infentry_ammunition_1: int = 100,
              infentry_ammunition_2: int = 100,
              drone_ammunition: int = 100,
              sentinel_ammunition: int = 100,
              # cmd_id=0x0a04
              cmd_id_4: int = 0x0A04,
              econmic_remain: int = 1000,
              economic_total: int = 0,
              supply_zone_occupation_status: int = 0,
              central_highland_occupation_status: int = 0,
              trapezoidal_highland_occupation_status: int = 0,
              fortress_bonus_points_occupation_status: int = 0,
          ):
              gr.sync_block.__init__(
                  self,
                  name="Message Value Generator",
                  in_sig=None,
                  out_sig=[np.float32],
              )
              self.hero_position = hero_position
              self.engineer_position = engineer_position
              self.infentry_position_1 = infentry_position_1
              self.infentry_position_2 = infentry_position_2
              self.drone_position = drone_position
              self.sentinel_position = sentinel_position

          def work(self, input_items, output_items):
              return len(output_items[0])
    central_highland_occupation_status: ''
    cmd_id_1: '2561'
    cmd_id_2: '2562'
    cmd_id_3: '2563'
    cmd_id_4: '2564'
    drone_ammunition: '100'
    drone_position: (0, 0)
    econmic_remain: '1000'
    economic_total: '0'
    engineer_blood: '200'
    engineer_position: (0, 0)
    fortress_bonus_points_occupation_status: ''
    hero_ammunition: '100'
    hero_blood: '200'
    hero_position: (0, 0)
    infentry_ammunition_1: '100'
    infentry_ammunition_2: '100'
    infentry_blood_1: '200'
    infentry_blood_2: '200'
    infentry_position_1: (0, 0)
    infentry_position_2: (0, 0)
    save_blood: '0'
    sentinel_ammunition: '100'
    sentinel_blood: '200'
    sentinel_position: (0, 0)
    supply_zone_occupation_status: '0'
    trapezoidal_highland_occupation_status: ''
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '1000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: signal_frequency
    gain1: '''manual'''
    manual_gain1: '60'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: 192.168.1.10
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '260000'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: sample_rate*2
    color1: '"dark blue"'
    ctrlpanel: 'True'
    fc: signal_frequency
    fftsize: '8192'
    label: db
    label1: frequency
    name: '"GFSK-signal频率图"'
    showports: 'True'
    type: complex
    update_time: '1'
    wintype: window.WIN_HAMMING
    ymax: '0'
    ymin: '-70'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: sample_rate*2
    color1: '"dark blue"'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '8192'
    label: db
    label1: frequency
    name: '"GFSK-signal频率图"'
    showports: 'True'
    type: complex
    update_time: '1'
    wintype: window.WIN_HAMMING
    ymax: '0'
    ymin: '-70'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: cyan
    ctrlpanel: 'True'
    grid: 'True'
    label1: signal_output_re
    marker1: '4'
    name: '"signal接收"'
    size: '2048'
    srate: sample_rate / SPS
    type: float
    update_time: '1'
    ymax: '6'
    ymin: '-6'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: cyan
    ctrlpanel: 'True'
    grid: 'True'
    label1: signal_output_re
    label2: signal_output_im
    marker1: '4'
    name: '"signal滤波输出"'
    size: '2048'
    srate: sample_rate*2
    type: complex
    update_time: '1'
    ymax: '6'
    ymin: '-6'
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0_1, '0']
- [digital_gfsk_demod_0, '0', blocks_char_to_float_0_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0_2, '0']

metadata:
  file_format: 1
