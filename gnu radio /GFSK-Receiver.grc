options:
  parameters:
    author: huangziang
    generate_options: qt_gui
    id: GFSK_Receiver
    output_language: python
    title: GFSK_Receiver
  states: {}

blocks:
- name: SPS
  id: variable
  parameters:
    value: '52'
  states: {}
- name: enemyside
  id: variable_qtgui_chooser
  parameters:
    label: 敌方颜色
    label0: 蓝方
    label1: 红方
    num_opts: '2'
    option0: blue
    option1: red
    type: string
    value: red
    widget: radio_buttons
  states: {}
- name: noise_bandwidth
  id: variable
  parameters:
    value: noise_configs[noise_grade_chooser][enemyside]["noise_bandwidth"]
  states: {}
- name: noise_configs
  id: variable
  parameters:
    value: |-
      {
          "noise_1": {
              "red": {
                  "noise_sensitivity": 2.8323,
                  "noise_frequency": 432200000,
                  "noise_bandwidth": 940000,
              },
              "blue": {
                  "noise_sensitivity": 2.8323,
                  "noise_frequency": 434920000,
                  "noise_bandwidth": 940000,
              },
          },
          "noise_2": {
              "red": {
                  "noise_sensitivity": 2.5809,
                  "noise_frequency": 432500000,
                  "noise_bandwidth": 860000,
              },
              "blue": {
                  "noise_sensitivity": 2.5809,
                  "noise_frequency": 434620000,
                  "noise_bandwidth": 860000,
              },
          },
          "noise_3": {
              "red": {
                  "noise_sensitivity": 0.6646,
                  "noise_frequency": 432800000,
                  "noise_bandwidth": 250000,
              },
              "blue": {
                  "noise_sensitivity": 0.6646,
                  "noise_frequency": 434320000,
                  "noise_bandwidth": 250000,
              },
          },
      }
  states: {}
- name: noise_frequency
  id: variable
  parameters:
    value: noise_configs[noise_grade_chooser][enemyside]["noise_frequency"]
  states: {}
- name: noise_grade_chooser
  id: variable_qtgui_chooser
  parameters:
    label: 干扰源等级
    label0: 一级干扰源
    label1: 二级干扰源
    label2: 三级干扰源
    num_opts: '3'
    option0: noise_1
    option1: noise_2
    option2: noise_3
    type: string
    value: noise_1
    widget: radio_buttons
  states: {}
- name: noise_sensitivity
  id: variable
  parameters:
    value: noise_configs[noise_grade_chooser][enemyside]["noise_sensitivity"]
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592653589793'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    value: '540000'
  states: {}
- name: signal_configs
  id: variable
  parameters:
    value: '{"red":{"signal_frequency":433200000},"blue":{"signal_frequency":433920000}}'
  states: {}
- name: signal_frequency
  id: variable
  parameters:
    value: signal_configs[enemyside]["signal_frequency"]
  states: {}
- name: signal_sensitivity
  id: variable
  parameters:
    value: '1.5756'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/pinkpanda/linux-RADAR/RADAR-2026/RADAR-SDR/receive.bin
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '15'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '15'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '0010111101101111010011000111010010111001000101000100100100101110'
    tagname: access_code+header
    threshold: '12'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '0001011011101000110100110111011100010101000111000111000100101101'
    tagname: access_code+header
    threshold: '12'
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.05'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.05'
    samples_per_symbol: SPS
    sensitivity: 1/signal_sensitivity
  states: {}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '52'
    sensitivity: 1/noise_sensitivity
  states: {}
- name: iio_pluto_source_1
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '432200000'
    gain1: '''manual'''
    manual_gain1: '60'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: 192.168.1.10
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '260000'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate*4
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '500000'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: byte
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2500'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: sample_rate*2
    color1: '"dark blue"'
    ctrlpanel: 'True'
    fc: signal_frequency
    fftsize: '8192'
    label: db
    label1: frequency
    name: '"GFSK-signal滤波后频率图"'
    showports: 'True'
    type: complex
    update_time: '1'
    wintype: window.WIN_HAMMING
    ymax: '0'
    ymin: '-70'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: sample_rate*2
    color1: '"dark blue"'
    ctrlpanel: 'True'
    fc: signal_frequency
    fftsize: '8192'
    label: db
    label1: frequency
    name: '"GFSK-频率图"'
    showports: 'True'
    type: complex
    update_time: '1'
    wintype: window.WIN_HAMMING
    ymax: '0'
    ymin: '-70'
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: sample_rate*2
    color1: '"dark blue"'
    ctrlpanel: 'True'
    fc: noise_frequency
    fftsize: '8192'
    label: db
    label1: frequency
    name: '"GFSK-noise滤波后频率图"'
    showports: 'True'
    type: complex
    update_time: '1'
    wintype: window.WIN_HAMMING
    ymax: '0'
    ymin: '-70'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: cyan
    ctrlpanel: 'True'
    grid: 'True'
    label1: signal_output_re
    marker1: '4'
    name: '"signal接收bits"'
    size: '2048'
    srate: sample_rate / SPS
    type: float
    update_time: '1'
    ymax: '6'
    ymin: '-6'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: cyan
    ctrlpanel: 'True'
    grid: 'True'
    label1: signal_output_re
    marker1: '4'
    name: '"noise接收bits"'
    size: '2048'
    srate: sample_rate / SPS
    type: float
    update_time: '1'
    ymax: '6'
    ymin: '-6'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: cyan
    ctrlpanel: 'True'
    grid: 'True'
    label1: signal_output_re
    label2: signal_output_im
    marker1: '4'
    name: '"signal滤波输出"'
    size: '2048'
    srate: sample_rate*2
    type: complex
    update_time: '1'
    ymax: '6'
    ymin: '-6'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: cyan
    ctrlpanel: 'True'
    grid: 'True'
    label1: signal_output_re
    label2: signal_output_im
    marker1: '4'
    name: '"noise滤波输出"'
    size: '2048'
    srate: sample_rate*2
    type: complex
    update_time: '1'
    ymax: '6'
    ymin: '-6'
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0_1, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0_1_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', network_tcp_sink_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', network_tcp_sink_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_gfsk_demod_0, '0', blocks_char_to_float_0_0, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_gfsk_demod_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [digital_gfsk_demod_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [iio_pluto_source_1, '0', low_pass_filter_0, '0']
- [iio_pluto_source_1, '0', low_pass_filter_0_0, '0']
- [iio_pluto_source_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0_2, '0']
- [low_pass_filter_0_0, '0', digital_gfsk_demod_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0_2_0, '0']

metadata:
  file_format: 1
