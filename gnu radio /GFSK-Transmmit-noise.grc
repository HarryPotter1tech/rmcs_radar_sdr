options:
  parameters:
    author: huangziang
    generate_options: qt_gui
    id: GFSK_Transmmit_noise
    output_language: python
    title: GFSK_Transmmit_noise
  states: {}

blocks:
- name: SPS
  id: variable
  parameters:
    value: '52'
  states: {}
- name: configs
  id: variable
  parameters:
    value: |-
      {
          "noise_1"
              : {"noise_sensitivity" : 2.8323, "noise_frequency" : 432200000, "noise_bandwidth" : 940000}
              , "noise_2"
              : {"noise_sensitivity" : 2.5809, "noise_frequency" : 432500000, "noise_bandwidth" : 860000}
              , "noise_3"
              : {"noise_sensitivity" : 0.6646, "noise_frequency" : 432800000, "noise_bandwidth" : 250000}
      }
  states: {}
- name: noise_bandwidth
  id: variable
  parameters:
    value: configs[noise_grade_chooser]["noise_bandwidth"]
  states: {}
- name: noise_frequency
  id: variable
  parameters:
    value: configs[noise_grade_chooser]["noise_frequency"]
  states: {}
- name: noise_grade_chooser
  id: variable_qtgui_chooser
  parameters:
    label: 干扰源等级
    label0: 一级干扰源
    label1: 二级干扰源
    label2: 三级干扰源
    num_opts: '3'
    option0: noise_1
    option1: noise_2
    option2: noise_3
    type: string
    value: noise_1
    widget: radio_buttons
  states: {}
- name: noise_sensitivity
  id: variable
  parameters:
    value: configs[noise_grade_chooser]["noise_sensitivity"]
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: selector_port
  id: variable
  parameters:
    value: '1'
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    value: '540000'
  states: {}
- name: signal_frequency
  id: variable
  parameters:
    value: '433200000'
  states: {}
- name: signal_sensitivity
  id: variable
  parameters:
    value: '1.5756'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/harryh/RADAR-2026/RADAR-SDR/launch/noisekey_package.bin
    repeat: 'True'
    type: byte
  states: {}
- name: digital_gfsk_mod_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    do_unpack: 'False'
    samples_per_symbol: SPS
    sensitivity: noise_sensitivity
    verbose: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: '1000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '432200000'
    samplerate: sample_rate
    type: fc32
    uri: 192.168.1.10
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: sample_rate
    color1: '"dark blue"'
    ctrlpanel: 'True'
    fc: '433200000'
    fftsize: '8192'
    name: '"GFSK-noise频率图"'
    showports: 'True'
    type: complex
    update_time: '0.5'
    wintype: window.WIN_FLATTOP
    ymax: '200'
    ymin: '-200'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    marker1: '2'
    name: '"noise输出"'
    size: '2048'
    srate: sample_rate
    type: complex
    update_time: '0.5'
    ymax: '6'
    ymin: '-6'
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gfsk_mod_0_0, '0']
- [digital_gfsk_mod_0_0, '0', iio_pluto_sink_0, '0']
- [digital_gfsk_mod_0_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_mod_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
